# Keil uVision project Boston Big Guy.uvprojx, settings and files
target Boston Big Guy (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIMER +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\BSP;..\HARDWARE;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c main.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h Action.c Action.h
  group HARDWARE
    ../HARDWARE/: led.c led.h AS5600.c AS5600.h MS5837.c MS5837.h JY901S.c JY901S.h A4988.c A4988.h Servo.c Servo.h Motor.c Motor.h
  group BSP
    ../BSP/: GPIO.c GPIO.h stmflash.c stmflash.h timer.c timer.h IIC.c IIC.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c usart.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_adc.c
  group ReadMe
    ./: ReadMe.txt
